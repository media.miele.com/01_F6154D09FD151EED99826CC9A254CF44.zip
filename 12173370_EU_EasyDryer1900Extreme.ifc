Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2022-11-09T11:05:17
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Nov 09 11:05:17 2022 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\0dd32ffb-e798-4f23-a96e-312fa1f5c011\6a868b85-1af7-4974-b424-0e7c1250deef\ifc * Database version: 5507 * Database creation date: Wed Nov 09 11:05:16 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Nov 09 11:05:16 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Nov 09 11:05:16 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12173370_EU_EasyDryer1900Extreme:52190001_EU_12173370_EasyDryer1900Extreme, (2)
In: Default
Type - Material: z_Miele_Design_BRWS
Type - Pset_BuildingElementProxyCommon - Reference: 52190001_EU_12173370_EasyDryer1900Extreme
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 52190001_EU_12173370_EasyDryer1900Extreme
Material: z_Miele_Design_BRWS, z_Miele_Connection_Electric, z_Miele_Design_OBSW, z_Miele_Design_Glass Black
Pset_BuildingElementProxyCommon - sets with these values: 2
